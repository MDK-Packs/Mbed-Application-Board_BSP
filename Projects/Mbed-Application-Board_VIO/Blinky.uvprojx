# Keil uVision project Blinky.uvprojx, settings and files
target Mbed-App-Board-RGB (6160000::V6.16::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  AfterMake: fromelf --bin -o Blinky.bin .\Objects\Blinky.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Sources
    ./: main.c Blinky.c main.h
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0, CMSIS Driver:VIO:Board 1.0.1
